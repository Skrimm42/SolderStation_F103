# IAR project Backup (3) of SolderStation_F103.ewp, settings and files
configuration SolderStation_F103 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Drivers/micromenu-2/inc; ../Drivers/sEEPROM/inc; ../Drivers/SSD1306_HAL_EN_RU-master/inc; ../Drivers/Buttons_drv/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SolderStation_F103.bin
  ILINK.IlinkOutputFile: SolderStation_F103.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: const_var.c menu.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/Button_drv
    ../Drivers/Buttons_drv/src/: button_drv.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/EEPROM
    ../Drivers/sEEPROM/src/: sEEPROM.c
  group Drivers/micromenu_2
    ../Drivers/micromenu-2/src/: MicroMenu.c
  group Drivers/SSD1306
    ../Drivers/SSD1306_HAL_EN_RU-master/src/: ssd1306.c ssd1306_fonts.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
